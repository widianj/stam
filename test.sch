v {xschem version=2.9.7 file_version=1.1}
G {}
V {}
S {}
E {}
C {devices/res.sym} 2250 250 0 0 {name=R1 value=1k}
