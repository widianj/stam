v {xschem version=2.9.7 file_version=1.1}
G {}
V {}
S {}
E {}
N 490 250 750 250 {lab=OUT}
C {devices/lab_wire.sym} 490 250 0 0 {lab=OUT}
N 490 500 620 500 {lab=OUT}
N 620 500 620 250 {lab=OUT}
N 620 250 750 250 {lab=OUT}
C {devices/lab_wire.sym} 490 500 0 0 {lab=OUT}
N 250 250 510 250 {lab=IN}
C {devices/lab_wire.sym} 250 250 0 0 {lab=IN}
N 250 250 380 250 {lab=IN}
N 380 250 380 500 {lab=IN}
N 380 500 510 500 {lab=IN}
C {devices/lab_wire.sym} 250 250 0 0 {lab=IN}
C {devices/ipin.sym} 250 250 0 0 {lab=IN}
C {devices/opin.sym} 750 250 0 0 {lab=OUT}
